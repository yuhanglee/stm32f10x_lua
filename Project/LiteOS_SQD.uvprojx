# Keil uVision project LiteOS_SQD.uvprojx, settings and files
target LiteOS_SQD (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LiteOS_SQD
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Project;.\USER;..\STM32FLib\CMSIS\CoreSupport;..\STM32FLib\CMSIS\DeviceSupport;..\STM32FLib\INC;.\USER\driver;.\USER\driver\Uart;.\USER\driver\Gprs;.\USER\driver\IWDG;.\USER\driver\Timer2;.\USER\driver\Delay;.\USER\driver\LCD;.\USER\MQTT;.\USER\driver\Ad7794;.\USER\driver\Spi;.\USER\driver\BH1750;.\USER\driver\DHT22;.\USER\driver\Gps;.\USER\driver\wind;.\USER\driver\eeprom;.\USER\driver\pressure;.\USER\driver\freq433;.\USER\driver\relay;.\USER\driver\led;.\USER\driver\lib;..\lua
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../STM32FLib/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../STM32FLib/CMSIS/CoreSupport/: core_cm3.c core_cm3.h
    ../STM32FLib/CMSIS/DeviceSupport/: system_stm32f10x.c stm32f10x.h system_stm32f10x.h
  group FWLB
    ../STM32FLib/SRC/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./USER/: main.c stm32f10x_it.c lua_uart.c malloc.c lua_cross.c
  group lua
    ../lua/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lundump.c lutf8lib.c lvm.c lzio.c
  group Driver
    ./USER/driver/: delay.c led.c
